options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: PruebaPAM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '100e-3'
    stop: '10'
    value: '1'
  states: {}
- name: D
  id: variable_qtgui_range
  parameters:
    label: Ancho pulso
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia mensaje
    start: '0'
    step: '10'
    stop: 10e3
    value: '100'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Pulsos
    start: '0'
    step: '1'
    stop: 10e3
    value: 1e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: ModuladorPAM_0
  id: ModuladorPAM
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    nconnections: '3'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [ModuladorPAM_0, '0', qtgui_freq_sink_x_0, '0']
- [ModuladorPAM_0, '0', qtgui_time_sink_x_0, '0']
- [ModuladorPAM_0, '1', qtgui_freq_sink_x_0, '2']
- [ModuladorPAM_0, '1', qtgui_time_sink_x_0, '2']
- [analog_sig_source_x_0, '0', ModuladorPAM_0, '0']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_0, '1']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
