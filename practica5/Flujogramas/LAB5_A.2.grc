options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: MultiplexaPAM
    output_language: python
    title: MultiplexaPAM
  states: {}

blocks:
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud del mesanaje
    start: '0'
    step: '100e-3'
    stop: '10'
    value: '1'
  states: {}
- name: D
  id: variable_qtgui_range
  parameters:
    label: Ancho Pulso
    start: '0'
    step: '1'
    stop: '50'
    value: '25'
  states: {}
- name: D1
  id: variable_qtgui_range
  parameters:
    label: retardo 1
    start: '0'
    step: '1'
    stop: '100'
    value: '25'
  states: {}
- name: D2
  id: variable_qtgui_range
  parameters:
    label: retardo 2
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: D3
  id: variable_qtgui_range
  parameters:
    label: retardo 3
    start: '0'
    step: '1'
    stop: '100'
    value: '75'
  states: {}
- name: D4
  id: variable_qtgui_range
  parameters:
    label: 'Selector '
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: W
  id: variable_qtgui_range
  parameters:
    label: ancho de pulso selector
    start: '0'
    step: '1'
    stop: '50'
    value: '25'
  states: {}
- name: fc_LPF
  id: variable_qtgui_range
  parameters:
    label: frecuencia filtro
    start: '0'
    step: '1'
    stop: 10e3
    value: '100'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia mensaje
    start: '0'
    step: '10'
    stop: 10e3
    value: '100'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: Frecuencia pulsos
    start: '0'
    step: '1'
    stop: 100e3
    value: samp_rate/100
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e6/128
  states: {}
- name: ModuladorPulsos_0
  id: ModuladorPulsos
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModuladorPulsos_0_0
  id: ModuladorPulsos
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModuladorPulsos_0_1
  id: ModuladorPulsos
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModuladorPulsos_0_2
  id: ModuladorPulsos
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModuladorPulsos_0_2_0
  id: ModuladorPulsos
  parameters:
    D: W
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: D1
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: D2
    type: float
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: D4
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: D3
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/com1_E1C_G1/GNURADIO_LABCOMUIS_2025_1_E1C_G1/practica5/Parte A/file_example_WAV_1MG.wav
    repeat: 'True'
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: fc_LPF
    decim: '1'
    gain: '4'
    samp_rate: samp_rate
    type: fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    nconnections: '2'
    type: float
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '5'
    size: 1024*4
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '2'
    size: 1024*8
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 200e6
    gain0: '10'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [ModuladorPulsos_0, '0', blocks_add_xx_0, '0']
- [ModuladorPulsos_0, '0', qtgui_time_sink_x_0, '0']
- [ModuladorPulsos_0_0, '0', blocks_delay_0, '0']
- [ModuladorPulsos_0_1, '0', blocks_delay_0_0, '0']
- [ModuladorPulsos_0_2, '0', blocks_delay_0_1, '0']
- [ModuladorPulsos_0_2_0, '0', blocks_float_to_complex_0, '0']
- [ModuladorPulsos_0_2_0, '0', filter_fft_low_pass_filter_0, '0']
- [ModuladorPulsos_0_2_0, '0', qtgui_freq_sink_x_0, '0']
- [ModuladorPulsos_0_2_0, '0', qtgui_time_sink_x_1, '0']
- [analog_sig_source_x_0, '0', ModuladorPulsos_0_0, '0']
- [analog_sig_source_x_0_0, '0', ModuladorPulsos_0, '0']
- [analog_sig_source_x_0_1, '0', ModuladorPulsos_0_1, '0']
- [analog_sig_source_x_0_2, '0', ModuladorPulsos_0_2, '0']
- [blocks_add_xx_0, '0', blocks_delay_0_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_delay_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0_0, '0', blocks_add_xx_0, '2']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0_0_0, '0', ModuladorPulsos_0_2_0, '0']
- [blocks_delay_0_1, '0', blocks_add_xx_0, '3']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0, '3']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_wavfile_source_0, '0', ModuladorPulsos_0, '0']
- [filter_fft_low_pass_filter_0, '0', qtgui_freq_sink_x_0, '1']
- [filter_fft_low_pass_filter_0, '0', qtgui_time_sink_x_1, '1']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
