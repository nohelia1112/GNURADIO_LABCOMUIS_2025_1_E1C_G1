options:
  parameters:
    author: EFREN
    generate_options: qt_gui
    id: CuantizadorClase
    output_language: python
    title: Cuantizador No uniforme UIS
  states: {}

blocks:
- name: U
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_Quantizer@0:1,0
    label: U law Constant
    start: '1'
    step: '1'
    stop: '256'
    value: '32'
  states: {}
- name: amplitude
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_source@0:1,0
    label: Amplitude
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
    widget: eng_slider
  states: {}
- name: fcut
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_channel@0:3,0
    label: cutoff frequency
    start: '0'
    step: '100'
    stop: '22050'
    value: '16000'
  states: {}
- name: n
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_Quantizer@0:1,1
    label: '# bit'
    start: '1'
    step: '1'
    stop: '12'
    value: '6'
    widget: eng_slider
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_channel@0:1,0
    label: Noise voltage
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '88200'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: math.pow(2,n)/amplitude
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amplitude/math.pow(2,n)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amplitude/math.pow(2,n)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: amplitude
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/com1_E1C_G1/GNURADIO_LABCOMUIS_2025_1_E1C_G1/practica5/Parte A/file_example_WAV_1MG.wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, mu=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.float32],\n            out_sig=[np.float32]\n        )\n      \n        self.mu = mu\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        output_items[0][:] = np.sign(input_items[0])*np.log(1+self.mu*np.abs(input_items[0]))/np.log(1+self.mu)\n        return len(output_items[0])\n"
    mu: U
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: fcut
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    grid: 'True'
    gui_hint: 3,0,4,2
    label1: '''Source'''
    label2: '''Channel'''
    label3: '''Companding'''
    label4: '''Quantization Noise'''
    name: '"Frequency"'
    nconnections: '4'
    type: float
    ymax: '-30'
    ymin: '-100'
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    bins: '10000'
    grid: 'True'
    gui_hint: 9,2,6,2
    name: '"Histogram Noise Q"'
    size: '8192'
    type: float
    xmax: '0.02'
    xmin: '-0.02'
  states: {}
- name: qtgui_histogram_sink_x_0_0
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    bins: '10000'
    grid: 'True'
    gui_hint: 9,0,2,2
    label1: Source
    label2: Companding
    marker2: '2'
    name: '"Histogram Source Vs Companding"'
    nconnections: '2'
    size: '8192'
    style2: '3'
    type: float
    xmax: '1.1'
    xmin: '-1.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,2,4,2
    label1: Source
    label2: Channel
    label3: Companding
    label4: Quantization Noise
    name: '"Time"'
    nconnections: '4'
    size: '20000'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '44100'
    interp: int(samp_rate)
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate)
    interp: int(25e6/64)
    type: ccc
  states: {}
- name: tab_Quantizer
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,2,1,2
    label0: Quantizer Controls
    num_tabs: '1'
  states: {}
- name: tab_channel
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,1,1,1
    label0: Channel Controls
    num_tabs: '1'
  states: {}
- name: tab_source
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,1
    label0: Source Controls
    num_tabs: '1'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '100000000'
    gain0: '10'
    samp_rate: int(25e6/64)
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: source
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: quantizer
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: channel
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Companding
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: NoiseQ
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: quantizer
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: source
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: Companding
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: Companding
  states: {}
- name: virtual_source_0_2_0
  id: virtual_source
  parameters:
    stream_id: NoiseQ
  states: {}
- name: virtual_source_0_2_0_0
  id: virtual_source
  parameters:
    stream_id: NoiseQ
  states: {}
- name: virtual_source_0_2_1
  id: virtual_source
  parameters:
    stream_id: Companding
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_110
  id: virtual_source
  parameters:
    stream_id: source
  states: {}
- name: virtual_source_110_0
  id: virtual_source
  parameters:
    stream_id: source
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: Companding
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_1, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', low_pass_filter_0, '0']
- [blocks_float_to_complex_1, '0', rational_resampler_xxx_1, '0']
- [blocks_float_to_short_0, '0', blocks_short_to_float_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_short_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', virtual_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_float_to_complex_1, '0']
- [blocks_multiply_const_vxx_0_1, '0', virtual_sink_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_sub_xx_0, '0', virtual_sink_0_0_0_0_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [epy_block_0, '0', virtual_sink_0_0_0_0, '0']
- [low_pass_filter_0, '0', virtual_sink_0_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle2_0, '0']
- [rational_resampler_xxx_1, '0', uhd_usrp_sink_0, '0']
- [virtual_source_0, '0', blocks_sub_xx_0, '0']
- [virtual_source_0_0, '0', blocks_add_xx_0, '0']
- [virtual_source_0_1, '0', blocks_sub_xx_0, '1']
- [virtual_source_0_1_0_0, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_0_1_0_0, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_0_2, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [virtual_source_0_2, '0', qtgui_freq_sink_x_0, '2']
- [virtual_source_0_2, '0', qtgui_time_sink_x_0, '2']
- [virtual_source_0_2_0, '0', qtgui_freq_sink_x_0, '3']
- [virtual_source_0_2_0, '0', qtgui_time_sink_x_0, '3']
- [virtual_source_0_2_0_0, '0', qtgui_histogram_sink_x_0, '0']
- [virtual_source_0_2_1, '0', qtgui_histogram_sink_x_0_0, '1']
- [virtual_source_1, '0', epy_block_0, '0']
- [virtual_source_110, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_110, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_110_0, '0', qtgui_histogram_sink_x_0_0, '0']
- [virtual_source_1_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
