options:
  parameters:
    author: NOHELIA
    category: '[Modulos Nohelia]'
    copyright: UIS
    generate_options: qt_gui
    id: salidaUSRP
    output_language: python
    title: MODULADOR AM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '10e-3'
    stop: '500e-3'
    value: '125e-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud m(t)
    start: '0'
    step: '100e-3'
    stop: '5'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: GTX
    start: '0'
    step: '1'
    stop: '30'
    value: '12'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Ka
    start: '0'
    step: '100e-3'
    stop: '5'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: '50'
    step: '1'
    stop: 2.2e3
    value: '150'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia m(t)
    start: '0'
    step: '1'
    stop: samp_rate/10
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12.5e6/16
  states: {}
- name: ModuladorAM_0
  id: ModuladorAM
  parameters:
    Ac: Ac
    Ka: Ka
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc*1e6
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [ModuladorAM_0, '0', qtgui_freq_sink_x_0, '0']
- [ModuladorAM_0, '0', qtgui_time_sink_x_0, '0']
- [ModuladorAM_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', ModuladorAM_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
