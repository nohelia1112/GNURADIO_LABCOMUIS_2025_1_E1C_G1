options:
  parameters:
    generate_options: qt_gui
    id: Practica3B2
    output_language: python
    title: Modulacion Amplitud
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '10e-3'
    stop: '500e-3'
    value: '125e-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '10e-3'
    stop: '2'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia
    start: '0'
    step: '1'
    stop: '30'
    value: '10'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia TX
    start: '50'
    step: '1'
    stop: 2.2e3
    value: '50'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje
    start: '0'
    step: '100'
    stop: 22.05e3
    value: '1000'
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente ka
    start: '0'
    step: '10e-3'
    stop: '2'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e6/32
  states: {}
- name: ModuladorAM_0
  id: ModuladorAM
  parameters:
    Ac: Ac
    Ka: ka
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/estudiante/Descargas/lab3/Audio_de_prueba.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '102400'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '44100'
    interp: int(samp_rate)
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc*1e6
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: m_t
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: m_t
  states: {}

connections:
- [ModuladorAM_0, '0', qtgui_freq_sink_x_0, '0']
- [ModuladorAM_0, '0', qtgui_time_sink_x_0, '0']
- [ModuladorAM_0, '0', uhd_usrp_sink_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', ModuladorAM_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
